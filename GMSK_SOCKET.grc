options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bit_rate_tx
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: rx_dec
  id: variable
  parameters:
    value: sps/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*bit_rate
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: sps*bit_rate_tx
  states: {}
- name: sps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
    sensitivity: 3.14/sps
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(sps/rx_dec)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (1+0.5)*(bit_rate/2)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/rx_dec
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate_tx
    stemplot: 'True'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(rx_dec)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(145e6, 5e6)
    clock_rate: '0.0'
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_tx
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(435e6, 5e6)
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: '80'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5500
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:5600
    maxInFlow: '5'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', zeromq_push_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_gmsk_demod_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_gmsk_demod_0, '0', blocks_uchar_to_float_0_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_sink_0_0, token_out, zeromq_req_source_0, token_in]
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']
- [zeromq_req_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [zeromq_req_source_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
